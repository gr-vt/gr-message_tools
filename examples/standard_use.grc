<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>message_tools_message_strobe_source</key>
<param><key>id</key><value>message_tools_message_strobe_source_0</value></param>
<param><key>file</key><value>/home/clark/workspace/2014-02-10/pybombs/src/gr-message_tools/examples/msg_file_format.dat</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>high</key><value>10</value></param>
<param><key>low</key><value>50</value></param>
</block>
<block>
<key>message_tools_message_file_sink</key>
<param><key>id</key><value>message_tools_message_file_sink_0</value></param>
<param><key>filename</key><value>/home/clark/workspace/2014-02-10/pybombs/src/gr-message_tools/examples/msg_file_out.dat</value></param>
<param><key>unbuffered</key><value>False</value></param>
<param><key>append</key><value>False</value></param>
</block>
<connection><source_block_id>message_tools_message_strobe_source_0</source_block_id><sink_block_id>message_tools_message_file_sink_0</sink_block_id><source_key>strobe</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
